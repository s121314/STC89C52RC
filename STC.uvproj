# Keil uVision project STC.uvproj, settings and files
target STC (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: STC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\lib
  group lib
    ./Sources/lib/: STC89C5xRC.H ansi.h txos.h
  group os
    ./Sources/txos/: os.h os.c
    ./Sources/txos/task/: os_stack.c os_task.c
    ./Sources/txos/timer/: os_timer.c
    ./Sources/txos/mail/: os_mail.c
  group dev
    ./Sources/dev/: led.h
  group main
    ./Sources/: main.c
  group dev_led
    ./Sources/dev/led/: led.h led.c led1.c led2.c
